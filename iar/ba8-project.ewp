# IAR project ba8-project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL17Z256xxx4 NXP MKL17Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL17Z256VLH4; DISABLE_WDOG
  ICCARM.CCIncludePath2: ..\3rdparty\madivaru-lib-v2\src\include; ..\3rdparty\SDK_2.7.0_MKL17Z256xxx4\devices\MKL17Z4; ..\3rdparty\SDK_2.7.0_MKL17Z256xxx4\devices\MKL17Z4\drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: ba8-project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group 3rdparty/KinetisSDK/devices/MKL17Z4
    ../3rdparty/SDK_2.7.0_MKL17Z256xxx4/devices/MKL17Z4/: fsl_device_registers.h MKL17Z4.h MKL17Z4_features.h system_MKL17Z4.c system_MKL17Z4.h
  group 3rdparty/KinetisSDK/devices/MKL17Z4/drivers
    ../3rdparty/SDK_2.7.0_MKL17Z256xxx4/devices/MKL17Z4/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_cop.c fsl_cop.h fsl_dac.c fsl_dac.h fsl_dma.c fsl_dma.h fsl_dmamux.c fsl_dmamux.h fsl_flash.h fsl_flexio.c fsl_flexio.h fsl_flexio_i2c_master.c fsl_flexio_i2c_master.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio_i2s_dma.c fsl_flexio_i2s_dma.h fsl_flexio_uart.c fsl_flexio_uart.h fsl_flexio_uart_dma.c fsl_flexio_uart_dma.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_dma.c fsl_i2c_dma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_dma.c fsl_lpuart_dma.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rtc.c fsl_rtc.h fsl_sai.c fsl_sai.h fsl_sai_dma.c fsl_sai_dma.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h fsl_tpm.c fsl_tpm.h fsl_uart.c fsl_uart.h fsl_uart_dma.c fsl_uart_dma.h fsl_vref.c fsl_vref.h
  group 3rdparty/KinetisSDK/devices/MKL17Z4/iar
    ../3rdparty/SDK_2.7.0_MKL17Z256xxx4/devices/MKL17Z4/iar/: startup_MKL17Z4.s
  group 3rdparty/madivaru-lib-v2/src/include
    ../3rdparty/madivaru-lib-v2/src/include/: mdv_common.h mdv_digital_input.h mdv_digital_output.h
  group src
    ../src/: main.c
