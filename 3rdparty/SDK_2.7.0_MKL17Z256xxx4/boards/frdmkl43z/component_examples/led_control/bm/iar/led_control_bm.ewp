# IAR project led_control_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL43Z256xxx4 NXP MKL43Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL43Z256VLH4; USB_STACK_BM=1; FSL_OSA_TASK_ENABLE=1; FRDM_KL43Z; FREEDOM; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MKL43Z4/drivers; ../../../../../../devices/MKL43Z4/utilities; ../../../../../../components/led; ../../../../../../devices/MKL43Z4/drivers; ../../../../../../components/timer_manager; ../../../../../../components/gpio; ../../../../../../components/button; ../../../../../../components/lists; ../../../../../../components/timer; ../../../../../../devices/MKL43Z4/drivers; ../../../../../../components/panic; ../../../../../../components/serial_manager; ../../../../../../components/serial_manager; ../../../../../../components/osa; ../../../../../../devices/MKL43Z4/drivers; ../../../../../../devices/MKL43Z4; ../../../../../../devices/MKL43Z4/utilities/str; ../../../../../../devices/MKL43Z4/utilities/debug_console; ../../../../../../components/uart; ../../../../../../devices/MKL43Z4/drivers; ../../../../../../devices/MKL43Z4/drivers; ../../../../../../devices/MKL43Z4/drivers; ../../../../../../devices/MKL43Z4/drivers; ../../../../../../devices/MKL43Z4/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: led_control_bm.out
  ILINK.IlinkIcfFile: MKL43Z256xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL43Z256VLH4; USB_STACK_BM=1; FSL_OSA_TASK_ENABLE=1; FRDM_KL43Z; FREEDOM; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: led_control.c
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MKL43Z4/drivers/: fsl_tpm.c fsl_tpm.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_clock.c fsl_clock.h fsl_lpuart.c fsl_lpuart.h fsl_uart.c fsl_uart.h fsl_port.h fsl_smc.c fsl_smc.h
  group utilities
    ../../../../../../devices/MKL43Z4/utilities/: fsl_shell.c fsl_shell.h fsl_assert.c
    ../../../../../../devices/MKL43Z4/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MKL43Z4/utilities/str/: fsl_str.c fsl_str.h
  group component/led
    ../../../../../../components/led/: led.c led.h
  group component/timer_manager
    ../../../../../../components/timer_manager/: timer_manager.c timer_manager.h
  group component/gpio
    ../../../../../../components/gpio/: gpio.h gpio_adapter.c
  group component/button
    ../../../../../../components/button/: button.c button.h
  group component/lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group component/timer
    ../../../../../../components/timer/: timer.h tpm_adapter.c
  group component/panic
    ../../../../../../components/panic/: panic.c panic.h
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group component/uart
    ../../../../../../components/uart/: lpuart_adapter.c uart.h
  group device
    ../../../../../../devices/MKL43Z4/: MKL43Z4.h MKL43Z4_features.h fsl_device_registers.h system_MKL43Z4.c system_MKL43Z4.h
  group startup
    ../../../../../../devices/MKL43Z4/iar/: startup_MKL43Z4.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
