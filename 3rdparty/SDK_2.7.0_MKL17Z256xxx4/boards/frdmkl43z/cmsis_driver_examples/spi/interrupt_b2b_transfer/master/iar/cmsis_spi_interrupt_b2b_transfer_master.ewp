# IAR project cmsis_spi_interrupt_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL43Z256xxx4 NXP MKL43Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL43Z256VLH4; FRDM_KL43Z; FREEDOM; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../CMSIS/Driver/Include; ../../../../..; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/MKL43Z4/drivers; ../../../../../../../devices/MKL43Z4/drivers; ../../../../../../../devices/MKL43Z4/drivers; ../../../../../../../devices/MKL43Z4/drivers; ../../../../../../../devices/MKL43Z4/drivers; ../../../../../../../devices/MKL43Z4/drivers; ../../../../../../../devices/MKL43Z4/drivers; ../../../../../../../devices/MKL43Z4/drivers; ../../../../../../../devices/MKL43Z4/cmsis_drivers; ../../../../../../../devices/MKL43Z4/drivers; ../../../../../../../devices/MKL43Z4; ../../../../../../../devices/MKL43Z4/utilities/str; ../../../../../../../devices/MKL43Z4/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../components/serial_manager; ../../../../../../../devices/MKL43Z4/drivers; ../../../../../../../devices/MKL43Z4/drivers; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../devices/MKL43Z4/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_spi_interrupt_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MKL43Z256xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL43Z256VLH4; FRDM_KL43Z; FREEDOM; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: cmsis_spi_interrupt_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MKL43Z4/drivers/: fsl_port.h fsl_clock.c fsl_clock.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_dma.c fsl_dma.h fsl_dmamux.c fsl_dmamux.h fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h fsl_common.c fsl_common.h fsl_uart.c fsl_uart.h fsl_smc.c fsl_smc.h
    ../../../../../../../devices/MKL43Z4/cmsis_drivers/: fsl_spi_cmsis.c fsl_spi_cmsis.h
  group device
    ../../../../../../../devices/MKL43Z4/: MKL43Z4.h MKL43Z4_features.h fsl_device_registers.h system_MKL43Z4.c system_MKL43Z4.h
  group utilities
    ../../../../../../../devices/MKL43Z4/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MKL43Z4/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MKL43Z4/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../../devices/MKL43Z4/iar/: startup_MKL43Z4.s
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm0plus.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
